VERSION 5.8 ;
BUSBITCHARS "[]" ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS
LAYER metal1
  TYPE ROUTING ;
END metal1
MACRO INVX1
  CLASS CORE ;
  SIZE 1.2 BY 2.4 ;
END INVX1
MACRO NAND2X1
  CLASS CORE ;
  SIZE 1.8 BY 2.4 ;
END NAND2X1
END LIBRARY
